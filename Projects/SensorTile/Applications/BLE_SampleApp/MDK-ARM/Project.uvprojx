# Keil uVision project Project.uvprojx, settings and files
target STM32L476JG_SensorTile (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476JGYx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BLE_SampleApp +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32L476xx,USE_HAL_DRIVER,USE_STM32L4XX_NUCLEO,STM32_SENSORTILE
  c misc: --no_conditionalize
  c include: ..\Inc;..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\..\Drivers\BSP\SensorTile;..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\Drivers\BSP\Components\lsm6dsm;..\..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\..\Drivers\BSP\Components\lps22hb;..\..\..\..\..\Drivers\BSP\Components\lsm303agr;..\..\..\..\..\Drivers\BSP\Components\stc3115;..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\..\..\..\Middlewares\ST\X-CUBE-BLE1_BlueNRG-MS\utils;..\..\..\..\..\Middlewares\ST\X-CUBE-BLE1_BlueNRG-MS\includes;..\..\..\..\..\Middlewares\ST\X-CUBE-BLE1_BlueNRG-MS\hci\hci_tl_patterns\Basic
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
  group User
    ../Src/: main.c sensor_service.c stm32l4xx_hal_msp.c stm32l4xx_it.c TargetPlatform.c usbd_cdc_interface.c usbd_conf.c usbd_desc.c stm32l4xx_hal_exti.c hci_tl_interface.c mci_hw_gpio.c mci_hw_timer.c
    ../Inc/: mci_hw_gpio.h mci_hw_timer.h
  group Keil
    ./: startup_stm32l476xx.s
  group Middlewares/ST/STM32_BlueNRG
    ../../../../../Middlewares/ST/X-CUBE-BLE1_BlueNRG-MS/hci/: hci_le.c
    ../../../../../Middlewares/ST/X-CUBE-BLE1_BlueNRG-MS/hci/hci_tl_patterns/Basic/: hci_tl.c
    ../../../../../Middlewares/ST/X-CUBE-BLE1_BlueNRG-MS/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_IFR.c bluenrg_l2cap_aci.c bluenrg_updater_aci.c bluenrg_utils_small.c
    ../../../../../Middlewares/ST/X-CUBE-BLE1_BlueNRG-MS/utils/: ble_list.c
  group Drivers/STM32L4xx-Nucleo
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_ll_usb.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../../../../Drivers/BSP/Components/lps22hb/: lps22hb.c lps22hb_reg.c
  group Drivers/BSP/SensorTile
    ../../../../../Drivers/BSP/SensorTile/: SensorTile.c SensorTile_env_sensors.c SensorTile_env_sensors_ex.c SensorTile_bus.c
  group Middlewares/ST/STM32_USB_Device_Library
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
software components: CMSIS:CORE 4.3.0
